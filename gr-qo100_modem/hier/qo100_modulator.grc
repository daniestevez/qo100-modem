options:
  parameters:
    author: Daniel Estevez
    category: '[QO-100 modem]'
    generate_options: hb
    id: qo100_modulator
    output_language: python
    title: QO-100 32APSK+pilot modulator
  states: {}

blocks:
- name: nfilt
  id: variable
  parameters:
    value: '64'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, constants.tdm_rate - 1)
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: constants.pilot_prbs
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    comment: 32APSK data symbols
    constellation: constants.constellation_32apsk
  states: {}
- name: digital_constellation_encoder_bc_1
  id: digital_constellation_encoder_bc
  parameters:
    comment: BPSK pilot symbols
    constellation: constants.constellation_bpsk
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constants.symbol_map_rev_32apsk
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: data_in
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: RRC filter and resample
    nfilts: nfilt
    rrate: constants.sps
    taps: firdes.root_raised_cosine(nfilt, nfilt, 1, constants.rrc_alpha, nfilt * 47)
    type: ccf
  states: {}

connections:
- [blocks_stream_mux_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_encoder_bc_1, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_stream_mux_0, '1']
- [digital_constellation_encoder_bc_1, '0', blocks_stream_mux_0, '0']
- [digital_map_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [pad_source_0, '0', digital_map_bb_0, '0']
- [pfb_arb_resampler_xxx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
