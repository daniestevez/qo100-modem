options:
  parameters:
    author: Daniel Estevez
    category: '[QO-100 modem]'
    generate_options: hb_qt_gui
    id: qo100_demodulator_gui
    output_language: python
    title: QO-100 32APSK+pilot demodulator (GUI)
  states: {}

blocks:
- name: ber_calc_0
  id: ber_calc
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: constants.tdm_rate - 1
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: data
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: pilot
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qo100_demodulator_0
  id: qo100_demodulator
  parameters:
    symbol_sync_bw: symbol_sync_bw
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    label1: 32APSK data
    label2: BPSK pilot
    nconnections: '2'
    size: int(constants.baudrate*(constants.tdm_rate-1)/constants.tdm_rate)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: constants.samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    label: PSD
    label1: Spectrum
    label2: Mirrored spectrum
    name: Received spectrum
    nconnections: '2'
    type: complex
    update_time: '0.1'
    ymax: '-25'
    ymin: '-65'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: qtgui_tab_widget_0@4:0,0
    max: '50'
    min: '0'
    name: BER %
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Clock recovery
    label2: Constellation
    label3: Synchronization
    label4: BER
    num_tabs: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@1:0,0
    label1: Instant symbol period
    label2: Average symbol period
    nconnections: '2'
    size: constants.baudrate
    srate: constants.baudrate
    type: float
    ymax: constants.sps*1.001
    ymin: constants.sps*0.999
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@3:0,0
    size: constants.tdm_rate*len(constants.pilot_prbs)*3
    srate: constants.samp_rate
    type: float
    ymax: 1.2e5
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@1:1,0
    label1: TED error
    size: constants.baudrate
    srate: constants.baudrate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@3:1,0
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: BPSK pilots
    size: len(constants.pilot_prbs)*3
    srate: constants.baudrate/constants.tdm_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: qtgui_tab_widget_0@4:1,0
    label1: BER
    legend: 'False'
    marker1: '0'
    size: '12'
    srate: constants.baudrate * (constants.tdm_rate - 1) / constants.tdm_rate * 5 * 1e-4
    type: float
    ylabel: BER %
    ymax: '50'
    ymin: '0'
  states: {}
- name: symbol_sync_bw
  id: parameter
  parameters:
    label: Symbol sync loop BW
    type: eng_float
    value: '0.01'
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Resync
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [ber_calc_0, '0', blocks_repeat_1, '0']
- [ber_calc_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_repeat_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_repeat_1, '0', qtgui_number_sink_0, '0']
- [pad_source_0, '0', blocks_conjugate_cc_0, '0']
- [pad_source_0, '0', qo100_demodulator_0, '0']
- [pad_source_0, '0', qtgui_freq_sink_x_0, '0']
- [qo100_demodulator_0, '0', ber_calc_0, '0']
- [qo100_demodulator_0, '0', pad_sink_0, '0']
- [qo100_demodulator_0, '0', qtgui_const_sink_x_0, '0']
- [qo100_demodulator_0, '1', blocks_repeat_0, '0']
- [qo100_demodulator_0, '1', pad_sink_0_0, '0']
- [qo100_demodulator_0, '1', qtgui_time_sink_x_0_2, '0']
- [qo100_demodulator_0, '2', qtgui_time_sink_x_0_1, '0']
- [qo100_demodulator_0, '3', qtgui_time_sink_x_0, '0']
- [qo100_demodulator_0, '4', qtgui_time_sink_x_0, '1']
- [qo100_demodulator_0, '5', blocks_complex_to_mag_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, qo100_demodulator_0, resync]

metadata:
  file_format: 1
