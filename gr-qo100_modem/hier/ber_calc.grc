options:
  parameters:
    author: Daniel Estevez
    category: '[QO-100 modem]'
    generate_options: hb
    id: ber_calc
    output_language: python
    title: BER calculator
  states: {}

blocks:
- name: data_file_path
  id: variable
  parameters:
    comment: Change this to point to the file containing the transmit data!!!
    value: '''/home/daniel/qo100-modem/32apsk/apsk32_data.u8'''
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: data_file_path
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '10000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 100/10000
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '5'
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constants.constellation_32apsk
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: constants.symbol_map_32apsk
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '1'
    eob_offset: '0'
    max_pdu_size: len(constants.pilot_prbs) * (constants.tdm_rate - 1)
    prepend: '[]'
    pub_det: 'False'
    rate: '1'
    start_tag: sync
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_xor_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_xor_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_1, '0']
- [digital_map_bb_1, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [pad_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [pdu_utils_tags_to_pdu_X_0, pdu_out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
