options:
  parameters:
    author: Daniel Estevez
    category: '[QO-100 modem]'
    generate_options: hb
    id: qo100_demodulator
    output_language: python
    title: QO-100 32APSK+pilot demodulator
  states: {}

blocks:
- name: nfilt
  id: variable
  parameters:
    value: '64'
  states: {}
- name: prbs_bipolar
  id: variable
  parameters:
    value: 2 * np.array(constants.pilot_prbs, 'float') - 1
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Symbol clock recovery and RRC filtering
    damping: '1.0'
    loop_bw: symbol_sync_bw
    max_dev: '0.001'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(nfilt, nfilt, 1/constants.sps, constants.rrc_alpha, nfilt * 127)
    resamp_type: digital.IR_PFB_MF
    sps: constants.sps
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1500'
    decim: '1'
    gain: '1'
    samp_rate: constants.samp_rate
    type: fir_filter_ccf
    width: '250'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: data
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: pilot
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: symbol_error
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: symbol_T_inst
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: symbol_T_avg
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: acquisition_fft
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: resync
    optional: 'True'
    type: message
  states: {}
- name: qo100_modem_acquisition_0
  id: qo100_modem_acquisition
  parameters:
    comment: PRBS phase and carrier frequency synchronization
    fft_oversample: '2'
    prbs: prbs_bipolar
    tdm_rate: constants.tdm_rate
    threshold: 7e4
  states: {}
- name: qo100_modem_pilot_pll_0
  id: qo100_modem_pilot_pll
  parameters:
    prbs: prbs_bipolar
    tdm_rate: constants.tdm_rate
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '4e-3'
    reference: '1.0'
  states: {}
- name: symbol_sync_bw
  id: parameter
  parameters:
    label: Symbol sync loop BW
    type: eng_float
    value: '0.01'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}

connections:
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [digital_symbol_sync_xx_0, '1', pad_sink_1, '0']
- [digital_symbol_sync_xx_0, '2', pad_sink_1_0, '0']
- [digital_symbol_sync_xx_0, '3', pad_sink_1_0_0, '0']
- [low_pass_filter_0, '0', satellites_rms_agc_0, '0']
- [pad_source_0, '0', low_pass_filter_0, '0']
- [pad_source_1, out, qo100_modem_acquisition_0, resync]
- [qo100_modem_acquisition_0, '0', qo100_modem_pilot_pll_0, '0']
- [qo100_modem_acquisition_0, '1', pad_sink_2, '0']
- [qo100_modem_pilot_pll_0, '0', pad_sink_0, '0']
- [qo100_modem_pilot_pll_0, '1', pad_sink_0_0, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', qo100_modem_acquisition_0, '0']

metadata:
  file_format: 1
