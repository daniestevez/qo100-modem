options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: loopback_test
    output_language: python
    title: QO-100 modem loopback test
  states: {}

blocks:
- name: cn0
  id: variable_qtgui_entry
  parameters:
    label: CN0 (dB)
    type: real
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: symbol_sync_bw
  id: variable_qtgui_entry
  parameters:
    label: Symbol sync BW
    type: real
    value: '0.01'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '32'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Change this to point to the file containing the transmit data!!!
    file: /home/daniel/qo100-modem/32apsk/apsk32_data.u8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.00'
    freq_offset: '-0.0002'
    noise_voltage: 10**(-cn0/20) * np.sqrt(samp_rate)
    seed: '0'
    taps: '1.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: qo100_demodulator_gui_0
  id: qo100_demodulator_gui
  parameters:
    symbol_sync_bw: symbol_sync_bw
  states: {}
- name: qo100_modulator_0
  id: qo100_modulator
  parameters: {}
  states: {}

connections:
- [analog_random_source_x_0, '0', qo100_modulator_0, '0']
- [blocks_file_source_0, '0', qo100_modulator_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qo100_demodulator_gui_0, '0']
- [qo100_modulator_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
