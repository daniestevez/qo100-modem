options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: recording_test
    output_language: python
    title: QO-100 modem recording test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: symbol_sync_bw
  id: variable_qtgui_entry
  parameters:
    label: Symbol sync BW
    type: real
    value: '0.01'
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    label: Tune frequency (Hz)
    type: real
    value: '-125'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '40e-3'
    freq: '-tune'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Change this to point to the file containing the IQ data!!!
    file: /home/daniel/qo100-modem/32apsk/32apsk_qo100_2021-04-11T13:17:58.710957_8ksps.c64
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: qo100_demodulator_gui_0
  id: qo100_demodulator_gui
  parameters:
    symbol_sync_bw: symbol_sync_bw
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', qo100_demodulator_gui_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
