options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: qo100_test
    output_language: python
    title: QO-100 modem over-the-air test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 750e3
  states: {}
- name: down_freq
  id: variable_qtgui_entry
  parameters:
    label: Downlink Frequency (offset from 10489 MHz)
    type: real
    value: 641.5e3
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: TX gain
    type: real
    value: '0.41'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 3.5e3
    gain: '1.0'
    samp_rate: 600e3
    width: 56.5e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: symbol_sync_bw
  id: variable_qtgui_entry
  parameters:
    label: Symbol sync BW
    type: real
    value: '0.01'
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    label: Tune frequency (Hz)
    type: real
    value: '-125'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '32'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: gain
    freq: down_freq - center_freq
    offset: '0'
    phase: '0'
    samp_rate: 600e3
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Change this to point to the file containing the transmit data!!!
    file: /home/daniel/qo100-modem/32apsk/apsk32_data.u8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: 1392//2
    n: (24+1392)//2
    offset: 24//2
    type: short
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**15
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 0.0.0.0
    port: '50100'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: down_freq - center_freq + tune
    decim: '5'
    samp_rate: 600e3
    taps: lowpass_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from qo100_modem import constants
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3.5e3
    decim: '15'
    gain: '4e-2'
    samp_rate: 120e3
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: transceiver_host
    mode: '1'
    port: transceiver_port
    type: short
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50100'
    src_zeros: 'False'
    type: short
  states: {state: disabled}
- name: qo100_demodulator_gui_0
  id: qo100_demodulator_gui
  parameters:
    symbol_sync_bw: symbol_sync_bw
  states: {}
- name: qo100_modulator_0
  id: qo100_modulator
  parameters: {}
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '75'
    type: ccc
  states: {}
- name: transceiver_host
  id: parameter
  parameters:
    type: str
    value: 10.203.134.11
  states: {}
- name: transceiver_port
  id: parameter
  parameters:
    type: intx
    value: '6000'
  states: {}

connections:
- [analog_random_source_x_0, '0', qo100_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_interleaved_short_0, '0', network_tcp_sink_0, '0']
- [blocks_file_source_0, '0', qo100_modulator_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_udp_source_0, '0', blocks_keep_m_in_n_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qo100_demodulator_gui_0, '0']
- [network_udp_source_0, '0', blocks_keep_m_in_n_0, '0']
- [qo100_modulator_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
